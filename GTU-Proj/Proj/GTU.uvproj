# Keil uVision project GTU.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ..\output\GTU +hex
  c flags: Optim=1 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ./: startup_stm32f10x_hd.s
  group User
    ../User/: include.h main.c basic_func.c sys_init.c app.c stm32f10x_it.c
  group Lib
    ../Lib/: STM32F10xR.LIB
